# Keil uVision project boot.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: boot +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\inc
  group Source Group 1
    ./: STARTUP.A51
    ../src/: main.c Lcd1602.c LedBuzzer.c keyboard.c DS1302.c DS18B20.c I2C.c eeprom.c
  group inc
    ../inc/: config.h Lcd1602.h LedBuzzer.h keyboard.h DS1302.h DS18B20.h I2C.h eeprom.h main.h
